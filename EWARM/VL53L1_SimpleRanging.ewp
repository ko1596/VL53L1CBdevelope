# IAR project VL53L1_SimpleRanging.ewp, settings and files
configuration VL53L1_SimpleRanging (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/BSP/Components/vl53l1; ../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../../../../../../Drivers\CMSIS\Include; ../../../../../../Drivers\BSP\53L1A2
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: VL53L1_SimpleRanging.bin
  ILINK.IlinkOutputFile: VL53L1_SimpleRanging.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f401xe.s
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c vl53l1_platform.c vl53l1_platform_ipp.c
  group Drivers/53L1A2
    ../../../../../../Drivers/BSP/53L1A2/: 53L1A2.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/VL53L1
    ../../../../../../Drivers/BSP/Components/vl53l1/: vl53l1_api.c vl53l1_api_calibration.c vl53l1_api_core.c vl53l1_api_debug.c vl53l1_api_preset_modes.c vl53l1_api_strings.c vl53l1_core.c vl53l1_core_support.c vl53l1_dmax.c vl53l1_error_strings.c vl53l1_hist_algos_gen3.c vl53l1_hist_algos_gen4.c vl53l1_hist_char.c vl53l1_hist_core.c vl53l1_hist_funcs.c vl53l1_nvm.c vl53l1_nvm_debug.c vl53l1_register_funcs.c vl53l1_sigma_estimate.c vl53l1_silicon_core.c vl53l1_wait.c vl53l1_xtalk.c vl53l1_zone_presets.c
